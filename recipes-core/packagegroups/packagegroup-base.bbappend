RDEPENDS:packagegroup-base-wifi:append:apalis-imx8 = " \
    mwifiex-delay \
"

RDEPENDS:packagegroup-base-wifi:append:colibri-imx8x = " \
    mwifiex-delay \
"

RDEPENDS:packagegroup-base-wifi:append:verdin-imx8mm = " \
    mwifiex-delay \
"
